# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177,1035
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\USER;..\TASK;..\Judge_System;..\Control_Algorithm;..\CAN_BUS;..\device;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c main.c main.h public.h configuration.h BSP.h BSP.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group TASK
    ../TASK/: Fault_Diagnosis_Task.c Fault_Diagnosis_Task.h CAN_Gimbal_Transmit.c CAN_Gimbal_Transmit.h can_send_task.c can_send_task.h chassis_task.c chassis_task.h control_task.c control_task.h power_task.c power_task.h
  group Control_algorithm
    ./: pid.c pid.h
    ../Control_Algorithm/: data_sample.c signal.c signal.h
  group ReadMe
    ../ReadMe/: ReadMe.txt
  group BSP
    ./: can.h can.c timer.c timer.h usart.c usart.h
  group CAN_BUS
    ../CAN_BUS/: CanBus.c CanBus.h
  group device
    ./: Dj6020.c Dj6020.h sensor.c sensor.h remote.c remote.h Super_Cap.c Super_Cap.h
    ../device/: ch040.c ch040.h
