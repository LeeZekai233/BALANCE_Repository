# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\README;..\HEADFILE;..\STLIB\inc;..\STLIB\src;..\APP\BAL\Ins;..\APP\RTOS\Ins;..\APP\TASK\CHASSIS_TASK\Inc;..\APP\TASK\GIMBAL_TASK\Ins;..\APP\TASK\SHOOT_TASK\Ins;..\BSP\can\Inc;..\BSP\delay\Inc;..\BSP\usart\Inc;..\BSP\sys\Inc;..\BSP\LED;..\EMBEDDED\CAN_BUS;..\EMBEDDED\senior\Auto_Shoot;..\EMBEDDED\senior\Auto_Shoot\proto;..\EMBEDDED\senior\Auto_Shoot\Protocol;..\EMBEDDED\senior\CH100;..\EMBEDDED\senior\DJI_MOTOR;..\EMBEDDED\senior\HI220;..\EMBEDDED\senior\HT430;..\EMBEDDED\senior\JUDGE;..\EMBEDDED\senior\LK_TECH;..\EMBEDDED\senior\PM01;..\EMBEDDED\senior_struct;..\EMBEDDED\senior\REMOTE;..\APP\TASK\MODE_SWITCH_TASK\Inc;..\BSP\timer\Inc;..\EMBEDDED\senior\CAN_CHASSIS_TRANSMIT;..\APP\TASK\WS2812B_TASK;..\APP\TASK\RC;..\APP\TASK\PID;..\APP\TASK\Motor;..\BSP\usart_o\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c BSP.c
  group RTOS
    ../APP/RTOS/Src/: control_task.c
    ./: control_task1.c control_task1.h
  group TASK
    ../APP/TASK/WS2812B_TASK/: WS2812B.c
    ../APP/TASK/RC/: RC.c
    ../APP/TASK/PID/: pid.c
    ../APP/TASK/Motor/: CAN_motor.c Motor.c
  group EMBEDDED
    ../EMBEDDED/senior_struct/: senior.c
    ../EMBEDDED/CAN_BUS/: CanBus.c
  group BSP
    ../BSP/can/Src/: can.c
    ../BSP/delay/Src/: delay.c
    ../BSP/sys/Sor/: sys.c
    ../BSP/LED/: led.c
    ../BSP/usart/Src/: usart.c
    ../BSP/usart_o/Src/: usart_o.c
    ../BSP/timer/Src/: timer.c
  group HEADFILE
    ../HEADFILE/: main.h public.h
  group STLIB
    ../STLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group README
    ../: readme.txt
    ../README/: fifo.h
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Compiler:I/O:STDERR 1.2.0
