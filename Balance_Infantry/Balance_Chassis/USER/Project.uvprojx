# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4
  c misc: --diag_suppress=177,1035
  c include: ..\FWLIB\inc;..\FWLIB\src;..\USER;..\Judge_System;..\SYSTEM;..\TASK;..\USER;..\Control_Algorithm;..\SYSTEM\CAN2;..\SYSTEM\TIM6;..\SYSTEM\USART1;..\SYSTEM\CAN1;..\SYSTEM\USART3;..\SYSTEM\USART6;..\SYSTEM\BSP;..\TASK\Remote_Task;..\SYSTEM\TIM2;..\TASK\Chassis_Task;..\Control_Algorithm\PID;..\FWLIB;..\SYSTEM\USART4;..\TASK\Leg_Task;..\MOTOR;..\TASK\Control_Task;..\TASK\Board_Connected_Task;..\DSP\Core_Include;..\DSP\PrivateInclude;..\DSP\Include;..\CORE;..\TASK\Whell_Observe_Task;..\Control_Algorithm\Ramp;..\TASK\Log_Task;..\Control_Algorithm\Low_Pass_Filter;..\TASK\Can_Bus_Task;..\Control_Algorithm\High_Pass_Filter;..\MOTOR\DaMiao_8009;..\MOTOR\DJI_Motor;..\SYSTEM\USART2;..\TASK\Super_Cap_Task;..\Control_Algorithm\Signal;..\Judge_System;..\SENSOR;..\SENSOR\TF02;..\SENSOR\vl53l4cx;..\SYSTEM\Delay
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c
  group CORE
    ../CORE/: main.c startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/USART1/: USART1.c
    ../SYSTEM/USART2/: USART2.c
    ../SYSTEM/USART3/: USART3.c
    ../SYSTEM/USART6/: USART6.c
    ../SYSTEM/USART4/: USART4.c
    ../SYSTEM/CAN1/: CAN1.c
    ../SYSTEM/CAN2/: CAN2.c
    ../SYSTEM/TIM6/: TIM6.c
    ../SYSTEM/TIM2/: TIM2.c
    ../SYSTEM/BSP/: BSP.c
    ../SYSTEM/Delay/: Delay.c
  group TASK
    ../TASK/Control_Task/: Control_Task.c
    ../TASK/Chassis_Task/: Chassis_Task.c
    ../TASK/Board_Connected_Task/: Board_Connected_Task.c
    ../TASK/Whell_Observe_Task/: Whell_Observe_Task.c
    ../TASK/Leg_Task/: Leg_Task.c
    ../TASK/Super_Cap_Task/: Super_Cap_Task.c
    ../TASK/Can_Bus_Task/: Can_Bus_Task.c
    ../TASK/Log_Task/: Log_Task.c
    ../TASK/Remote_Task/: Remote_Task.c
  group Judge_System
    ../Judge_System/: Judge_System.c client.c
  group Control_algorithm
    ../Control_Algorithm/PID/: PID.c
    ../Control_algorithm/Ramp/: Ramp.c
    ../Control_algorithm/High_Pass_Filter/: High_Pass_Filter.c
    ../Control_Algorithm/Low_Pass_Filter/: Low_Pass_Filter.c
    ../Control_Algorithm/Signal/: Signal.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
  group MOTOR
    ../MOTOR/DaMiao_8009/: DaMiao_8009.c
    ../MOTOR/DJI_Motor/: DJI_Motor.c
  group DSP
    ../DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_sub_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mat_inverse_f32.c
    ../DSP/Source/FastMathFunctions/: arm_atan2_f32.c arm_cos_f32.c arm_sin_f32.c
    ../DSP/Source/SupportFunctions/: arm_copy_f32.c
    ../DSP/Source/ControllerFunctions/: arm_sin_cos_f32.c
    ../DSP/Source/CommonTables/: arm_common_tables.c
  group SENSOR
    ../SENSOR/TF02/: TF02.c
    ../SENSOR/vl53l4cx/: vl53l4cx.c
