# Keil uVision project Project.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=177,1035
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB\src;..\USER;..\MOTOR\DJI_Motor;..\MOTOR\DM_4310;..\Judge_System;..\SYSTEM\BSP;..\SYSTEM\CAN1;..\SYSTEM\CAN2;..\SYSTEM\TIM2;..\SYSTEM\TIM6;..\SYSTEM\USART1;..\SYSTEM\USART2;..\SYSTEM\USART3;..\SYSTEM\USART4;..\SYSTEM\USART6;..\Control_Algorithm\High_Pass_Filter;..\Control_Algorithm\Low_Pass_Filter;..\Control_Algorithm\PID;..\Control_Algorithm\Ramp;..\Control_Algorithm\Signal;..\MOTOR\DJI_Motor;..\MOTOR\DM_4310;..\MOTOR\LK_TECH;..\TASK\Board_Connected_Task;..\TASK\Control_Task;..\TASK\Can_Bus_Task;..\TASK\Gimbal_Task;..\TASK\Shooter_Task;..\TASK\Remote_Task;..\Control_Algorithm\Shooter_Kalman_Filter
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c
  group CORE
    ../CORE/: main.c startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/BSP/: BSP.c
    ../SYSTEM/CAN1/: CAN1.c
    ../SYSTEM/CAN2/: CAN2.c
    ../SYSTEM/TIM2/: TIM2.c
    ../SYSTEM/TIM6/: TIM6.c
    ../SYSTEM/USART1/: USART1.c
    ../SYSTEM/USART2/: USART2.c
    ../SYSTEM/USART3/: USART3.c
    ../SYSTEM/USART4/: USART4.c
    ../SYSTEM/USART6/: USART6.c
  group TASK
    ../TASK/Shooter_Task/: Shooter_Task.c
    ../TASK/Can_Bus_Task/: Can_Bus_Task.c
    ../TASK/Control_Task/: Control_Task.c
    ../TASK/Gimbal_Task/: Gimbal_Task.c
    ../TASK/Board_Connected_Task/: Board_Connected_Task.c
    ../TASK/Remote_Task/: Remote_Task.c
  group Judge_System
    ../Judge_System/: Judge_System.c
  group Control_algorithm
    ../Control_Algorithm/High_Pass_Filter/: High_Pass_Filter.c
    ../Control_Algorithm/Low_Pass_Filter/: Low_Pass_Filter.c
    ../Control_Algorithm/PID/: PID.c
    ../Control_Algorithm/Ramp/: Ramp.c
    ../Control_Algorithm/Signal/: Signal.c
    ../Control_algorithm/Shooter_Kalman_Filter/: Shooter_Kalman_Filter.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
  group MOTOR
    ../MOTOR/DJI_Motor/: DJI_Motor.c
    ../MOTOR/LK_TECH/: LK.c
    ../MOTOR/DM_4310/: DM_Motor.c
